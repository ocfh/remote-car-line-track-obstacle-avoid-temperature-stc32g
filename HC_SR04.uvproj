# Keil uVision project HC_SR04.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: HC_SR04 +hex
  group Source Group 1
    ./: main.c
  group HARDWARE
    ./HARDWARE/src/: delay.c motor.c timer.c uart1.c sr04.c adc.c
